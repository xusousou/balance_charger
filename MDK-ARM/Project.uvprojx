# Keil uVision project Project.uvprojx, settings and files
target GD32E230K_START (6160000::V6.16::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS_RTOS;..\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\GD32E23x_Firmware_Library\CMSIS;..\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;..\HARDWORK;..\..\balance_charger
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../: main.c
  group SYSTEM
    ../: systick.c gd32e23x_it.c
  group HARDWORK
    ../HARDWORK/: board.c adc.c bq25703a_regulator.c control.c rgbled.c usart.c iic.c error.c battery.c key.c
  group GD32E23x_Peripherals
    ../GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Doc
    ../: readme.txt
  group CMSIS
    ../CMSIS_RTOS/: cmsis_os.c
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Coroutines 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, CMSIS:CORE 5.4.0, Device:Startup 1.0.0
